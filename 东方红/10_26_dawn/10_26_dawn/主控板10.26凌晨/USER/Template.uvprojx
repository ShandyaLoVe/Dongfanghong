# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE;..\HARDWARE\GPIO;..\HARDWARE\oled;..\HARDWARE\motor;..\HARDWARE\steer;..\HARDWARE\Ultrasonic;..\HARDWARE\usart_my;..\HARDWARE\light;..\HARDWARE\USART2_DMA;..\CONTROL\PID;..\CONTROL\System_operation;..\CONTROL\Move_command;..\CONTROL\work;..\HARDWARE\USART1_DMA;..\HARDWARE\USART4_DMA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../HARDWARE/: Test.c
  group CONTROL
    ../CONTROL/System_operation/: System_operation.c
    ../CONTROL/PID/: PID.c
    ../CONTROL/Move_command/: Move_command.c
    ./: pid_small.c pid_small.h
  group HARDWARE
    ../HARDWARE/GPIO/: led.c key.c
    ../HARDWARE/oled/: oled.c
    ../HARDWARE/motor/: motor.c encoder.c
    ../HARDWARE/steer/: steer.c
    ../HARDWARE/Ultrasonic/: Ultrasonic.c
    ../HARDWARE/usart_my/: usart_my.c
    ../HARDWARE/USART2_DMA/: usart2_dma.c
    ../HARDWARE/light/: light.c
    ../HARDWARE/USART1_DMA/: usart1_dma.c
    ../HARDWARE/USART4_DMA/: usart4_dma.c
    ./: mike.c mike.h step.c step.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
