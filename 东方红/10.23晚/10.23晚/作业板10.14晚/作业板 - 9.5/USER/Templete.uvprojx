# Keil uVision project Templete.uvprojx, settings and files
target Templete (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Templete +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\UART;..\HARDWARE\OLED;..\HARDWARE\WT1;..\SYSTEM\PWM;..\HARDWARE\MOTOR;..\HARDWARE\SERVO;..\HARDWARE\OPENMV;..\SYSTEM\PID;..\SYSTEM\IIC;..\HARDWARE\TRACKING;..\SYSTEM\TIMER;..\HARDWARE\SW;..\HARDWARE\LASER;..\BSP;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/PWM/: PWM.c
    ../SYSTEM/PID/: PID.c PID.h
    ../SYSTEM/IIC/: iic.h iic.c
    ../SYSTEM/TIMER/: timer.c timer.h
  group HARDWARE
    ../HARDWARE/LED/: LED.c LED.h
    ../HARDWARE/BEEP/: beep.c beep.h
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/WT1/: WT1.c WT1.h
    ../HARDWARE/MOTOR/: motor.h motor.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/OPENMV/: OPENMV.c OPENMV.h
    ../HARDWARE/TRACKING/: tracking.c tracking.h
    ../HARDWARE/LASER/: laser.c laser.h
    ./: col_xy.c col_xy.h encoder.c encoder.h task.c task.h usart4_dma.c usart4_dma.h
    ../HARDWARE/SW/: SW.c SW.h
  group USER
    ./: stm32f4xx_it.c system_stm32f4xx.c main.c command.c command.h
